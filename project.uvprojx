# Keil uVision project project.uvprojx, settings and files
target project (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ESEL ELITTLE
  output: project +hex
  group platform
    ./system/: startup_cm4.S system_cm4.c printf-stdarg.c
  group driver
    ./peripheral/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_uart.c tremo_wdg.c
  group app
    ./src/: main.c tremo_it.c Lora_Demo.c
    ./src/user/: APP.c APP.h
    ./src/user/lora_profile/: STM8_armcode.c
  group Lora
    ./driver/: rtc-board.c sx1262-board.c utilities.c
    ./system/: delay.c timer.c
    ./radio/sx126x/: sx126x.c radio.c
  group modbus
    ./src/modbus/: Modbus_Core.c Modbus_CRC.c Modbus_hook.c Modbus_User.c
  group Lora_Profile
    ./src/user/lora_profile/: lora_at_cmd.c lora_at_cmd.h lora_cmd_m.c lora_cmd_s.c lora_core.c lora_core.h lora_flash.c lora_flash.h lora_function.c lora_user.c lora_user.h ymodem.c ymodem.h SendPacket.c
  group modbus_master
    ./src/modbus_Master/: mb_hook.c mb_host.c mb_port.c ringbuff.c
  group mbs_ctrl
    ./src/user/roomctrl/: DAC_Ctrl.c KEY_Ctrl.c LED_595_Ctrl.c MBS_Cmd_Ctrl.c Relay_Ctrl.c RGB_Ctrl.c SCR_Ctrl.c
